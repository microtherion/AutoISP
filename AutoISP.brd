# Repository microtherion/AutoISP

## EAGLE design AutoISP.brd

Parts:
BOARD: AVR_SPI_PRG_6PTH; 2X3
LED1: LED1206; LED-1206
MCU: AVR_SPI_PRG_6PTH; 2X3
PROG: AVR_SPI_PRG_6PTH; 2X3
R1: 10kΩ; 0603-RES
R2: 1kΩ; 0603-RES
U$1: STMAV340TTR; TSSOP-16

Connections:
unnamed: LED1.C, PROG.5, R1.1, U$1.1 (1B), U$1.14 (S)
unnamed: PROG.4, U$1.3 (2B)
unnamed: PROG.1, U$1.5 (3B)
unnamed: PROG.3, U$1.7 (4B)
unnamed: BOARD.5, U$1.2 (1C)
unnamed: BOARD.6, MCU.6, PROG.6, U$1.9 (GND), U$1.15 (!OE)
unnamed: BOARD.2, MCU.2, PROG.2, R1.2, R2.2, U$1.16 (VCC)
unnamed: BOARD.4, U$1.4 (2C)
unnamed: BOARD.1, U$1.6 (3C)
unnamed: BOARD.3, U$1.8 (4C)
unnamed: MCU.5, U$1.13 (1A)
unnamed: MCU.4, U$1.12 (2A)
unnamed: MCU.1, U$1.11 (3A)
unnamed: MCU.3, U$1.10 (4A)
unnamed: LED1.A, R2.1

Board: 2 copper layers, 27.9 x 16.5 mm, 9 parts (0 on the bottom side), 15 nets.

Other parts of the board:
U$2: ROBOXTEC-VECLOGO-NANO
U$3: OSHW-LOGO-S

## EAGLE design AutoISP84.brd

Parts:
J1: MCU; 2X3
J2: BOARD; 2X3
JP1, JP2: M07; 1X07
U1: ATTINY84-20PU; DIP254P762X533-14

Connections:
unnamed: J1.2, U1.1 (VCC)
unnamed: J2.2, JP1.1
unnamed: J2.6, JP2.7
unnamed: J1.6, U1.14 (GND)
unnamed: J1.5, U1.4 (PB3)
unnamed: J1.3, U1.9 (PA4)
unnamed: J2.5, JP1.4
unnamed: J1.4, U1.7 (PA6)
unnamed: J1.1, U1.8 (PA5)
unnamed: JP2.6, U1.13 (PA0)
unnamed: JP1.5, U1.5 (PB2)
unnamed: JP1.3, U1.3 (PB1)
unnamed: JP1.2, U1.2 (PB0)
unnamed: JP1.6, U1.6 (PA7)
unnamed: JP2.5, U1.12 (PA1)
unnamed: J2.4, JP1.7
unnamed: JP2.4, U1.11 (PA2)
unnamed: JP2.3, U1.10 (PA3)
unnamed: J2.1, JP2.1
unnamed: J2.3, JP2.2

Board: 2 copper layers, 33.0 x 16.5 mm, 7 parts (0 on the bottom side), 20 nets.

Other parts of the board:
U$1: OSHW-LOGO-S
U$2: ROBOXTEC-VECLOGO-MICRO

## EAGLE design AutoISP85.brd

Parts:
CN1, CN3: 1X4-CLEANBIG; 1X04-CLEANBIG
J1: MCU; 2X3
J2: BOARD; 2X3
U1: TINY85-20-DIP; DIP08

Connections:
unnamed: J1.5, U1.1 (PB5(NRES))
unnamed: J1.2, U1.8 (VCC)
unnamed: J1.6, U1.4 (GND)
unnamed: J1.4, U1.5 (PB0(MOSI))
unnamed: CN1.1, J2.5
unnamed: CN1.2, U1.2 (PB3(ADC3))
unnamed: CN1.3, U1.3 (PB4(ADC2))
unnamed: CN1.4, J2.6
unnamed: CN3.1, J2.4
unnamed: CN3.2, J2.1
unnamed: CN3.3, J2.3
unnamed: CN3.4, J2.2
unnamed: J1.1, U1.6 (PB1(MISO))
unnamed: J1.3, U1.7 (PB2(SCK/ADC1))

Board: 2 copper layers, 24.1 x 16.5 mm, 7 parts (1 on the bottom side), 14 nets.

Other parts of the board:
U$1: ROBOXTEC-VECLOGO-MICRO
U$2: OSHW-LOGO-S

## EAGLE design AutoISP328.brd

Parts:
J1: MCU; 2X3
J2: BOARD; 2X3
JP1, JP2: M14; 1X14
U1: ATMEGA328P_PDIP; DIL28-3

Connections:
unnamed: J1.5, U1.1 (PC6(/RESET))
unnamed: J1.2, U1.7 (VCC), U1.20 (AVCC)
unnamed: J1.6, U1.8 (GND), U1.22 (GND)
unnamed: J1.4, U1.17 (PB3(MOSI/OC2))
unnamed: J1.1, U1.18 (PB4(MISO))
unnamed: J1.3, U1.19 (PB5(SCK))
unnamed: J2.3, JP1.5
unnamed: J2.1, JP1.4
unnamed: J2.6, JP1.8, JP2.8
unnamed: JP1.14, U1.28 (PC5(ADC5/SCL))
unnamed: J2.4, JP1.3
unnamed: J2.2, JP1.6, JP2.7
unnamed: J2.5, JP2.1
unnamed: JP1.7, U1.21 (AREF)
unnamed: JP2.9, U1.9 (PB6(XTAL1/TOSC1))
unnamed: JP2.10, U1.10 (PB7(XTAL2/TOSC2))
unnamed: JP1.13, U1.27 (PC4(ADC4/SDA))
unnamed: JP1.12, U1.26 (PC3(ADC3))
unnamed: JP1.11, U1.25 (PC2(ADC2))
unnamed: JP1.10, U1.24 (PC1(ADC1))
unnamed: JP1.9, U1.23 (PC0(ADC0))
unnamed: JP2.2, U1.2 (PD0(RXD))
unnamed: JP2.3, U1.3 (PD1(TXD))
unnamed: JP2.4, U1.4 (PD2(INT0))
unnamed: JP2.5, U1.5 (PD3(INT1))
unnamed: JP2.6, U1.6 (PD4(XCK/T0))
unnamed: JP2.11, U1.11 (PD5(T1))
unnamed: JP2.12, U1.12 (PD6(AIN0))
unnamed: JP2.13, U1.13 (PD7(AIN1))
unnamed: JP2.14, U1.14 (PB0(ICP))
unnamed: JP1.1, U1.15 (PB1(OC1A))
unnamed: JP1.2, U1.16 (PB2(SS/OC1B))

Board: 2 copper layers, 49.5 x 17.1 mm, 7 parts (0 on the bottom side), 32 nets.

Other parts of the board:
U$1: OSHW-LOGO-M
U$2: ROBOXTEC-VECLOGO-MICRO

## Commit log

2014-10-25 AutoISP{,85} 1.0 manufactured
2014-11-10 AutoISP 1.1, fixing reversed pins
2014-11-10 Added AutoISP84
2015-03-21 Add AutoISP manual
2015-03-21 Revise boards for better labelling and sane orientation, add AutoISP328
2015-04-29 AutoISP85 1.3 (Fix flipped pin header) Add BOM
2015-06-17 Add generated Gerbers
2015-08-15 Make polygon width nonzero
2015-08-15 Manual version 1.2

Notices in the files:
AutoISP.brd:
CC BY
AutoISP328.brd:
µTh '15  CC BY
parts and their libraries:
SparkFun-Connectors: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
